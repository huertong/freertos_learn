# Keil uVision project STM32F103_DLH.uvprojx, settings and files
target DLH (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32-DEMO +hex
  c flags: Optim=2 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: ..\Drivers\CMSIS;..\Drivers\FWlib\inc;..\User;..\FreeRTOS\include;..\FreeRTOS\port\RVDS\ARM_CM3;..\Core;..\Core\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group startup
    ../DRIVERS/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../Drivers/CMSIS/: core_cm3.c system_stm32f10x.c
  group FWlib
    ../Drivers/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group User
    ../User/: bsp_usart.c
  group FreeRTOS/src
    ../FreeRTOS/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/port
    ../FreeRTOS/port/RVDS/ARM_CM3/: port.c
    ../FreeRTOS/port/MemMang/: heap_4.c
  group Core
    ../Core/: main.c stm32f10x_it.c FreeRTOSConfig.h
software components: CMSIS:CORE 5.0.1
